options:
  parameters:
    author: camozeen
    generate_options: qt_gui
    id: integration_test_grc_source
    output_language: python
    title: GRC UDP Source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/camozeen/Src/aprs_forwarder/test/integration_test_data.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '7355'
    send_eof: 'False'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
